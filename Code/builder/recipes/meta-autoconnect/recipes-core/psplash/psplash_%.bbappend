FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SPLASH_IMAGES:rpi = "file://AutoConnect.jpg-img.h;outsuffix=raspberrypi"
